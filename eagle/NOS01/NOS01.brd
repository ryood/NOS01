# Repository ryood/NOS01

## EAGLE design eagle/NOS01/NOS01.brd

Parts:
C1, C2: 47uF; E2,5-6
C3, C4: 1uF; C050-045X075
C5: 0.1uF; C075-052X106
C6: 0.01uF; C050-045X075
C7, C8, C9, C10: 0.1uF; C025-024X044
IC1, IC2: TL072P; DIL08
JP1, JP2: PWR; 1X03
JP3: TP_GND; 1X02
JP4, JP7: WHITE; 1X02
JP5, JP8: PINK; 1X02
JP6, JP9: BLUE; 1X02
LED1: GREEN; LED3MM
R1, R2, R4, R7, R9, R10, R13: 10k; 0207/7
R3, R6, R11: 100k; 0207/7
R5: 330k; 0207/7
R8: 100k; B25P
R12, R15, R16, R17: 1k; 0207/7
R14: 22k; 0207/7
T1, T2: 2SC1815; TO92-ECB

Connections:
GND: C1.-, C2.+, C5.2, C7.2, C8.1, C9.2, C10.1, JP1.2, JP2.2, JP3.1, JP3.2, JP4.2, JP5.2, JP6.2, JP7.2, JP8.2, JP9.2, R3.1, R4.1, R6.1, R7.1, R10.1, R12.1, R13.1
unnamed: T1.B, T2.B
unnamed: C3.1, R2.1, T1.E, T2.C
unnamed: C3.2, IC1.3 (+IN), R3.2
unnamed: LED1.A, R1.1
unnamed: IC1.2 (-IN), R4.2, R5.1
unnamed: IC2.2 (-IN), R10.2, R11.1
unnamed: C4.1, IC1.1 (OUT), R5.2
unnamed: C4.2, IC1.5 (+IN), R6.2
unnamed: IC1.6 (-IN), R7.2, R8.A
unnamed: C6.1, IC1.7 (OUT), R8.E, R8.S, R9.1, R15.1
unnamed: IC2.1 (OUT), R11.2, R16.1
unnamed: JP5.1, JP8.1, R16.2
unnamed: C5.1, IC2.3 (+IN), R9.2
unnamed: IC2.6 (-IN), R13.2, R14.1
unnamed: IC2.7 (OUT), R14.2, R17.1
unnamed: C6.2, IC2.5 (+IN), R12.2
unnamed: JP4.1, JP7.1, R15.2
unnamed: JP6.1, JP9.1, R17.2
V+: C1.+, C7.1, C9.1, IC1.8 (V+), IC2.8 (V+), JP1.1, JP2.1, R1.2, R2.2
V-: C2.-, C8.2, C10.2, IC1.4 (V-), IC2.4 (V-), JP1.3, JP2.3, LED1.K (C), T2.E

Notes on the sheet:
T1はピンソケットで実装

Board: 2 copper layers, 93.7 x 71.1 mm, 41 parts (0 on the bottom side), 21 nets.

## Commit log

2017-09-28 Add: eagle files
2017-09-30 add a board design
2017-09-30 Update eagle files
2017-11-09 Update board design
